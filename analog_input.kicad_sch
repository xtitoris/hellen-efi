File: analog_input.kicad_sch (KiCad schematic)
At the start: 20 parts, among them U17 SRV05-4, U18 MCP6004

Commit message: Pre-cleanup
Parts:
- C27, C28, C29, C30, C31: LCSC_ext 0 -> Basic
