File: etb-9201.kicad_sch (KiCad schematic)
At the start: 5 parts, among them U27 TLE9201SG

Commit message: Pre-cleanup
Parts:
- C69, C70, C71: LCSC_ext 0 -> Basic
- U27: LCSC_ext 1 -> Extended
